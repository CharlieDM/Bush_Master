# Keil uVision project MultiSPI.uvprojx, settings and files
target MultiSPI (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.4
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bush_Main_485_ID1_0910 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL
  c include: ..\App;..\Core;..\Cpu\STM32F10x_StdPeriph_Driver\inc;..\Cpu\CMSIS\CM3\CoreSupport;..\Cpu\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Cpu\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup;..\Driver\Dev;..\Driver\Dev\IO;..\Driver\Dev\ModSlave;..\Driver\MCU;..\Pub;..\Utility
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP
    ../App/: main.c app.c
  group Core
    ../Core/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h Core_hal.c Core_os.c
  group Cpu.CMSIS
    ../Cpu/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Cpu/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../Cpu/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_cl.s
  group Cpu.Lib
    ../Cpu/STM32F10x_StdPeriph_Driver/src/: STM32F105.lib
  group Driver.MCU
    ../Driver/MCU/: hal_uart5.c hal_uart5.h hal_uart3.c hal_uart3.h hal_spi.c hal_spi.h hal_systick.c hal_systick.h hal_gpio.c
  group Driver.Dev
    ../Driver/Dev/ModSlave/: modbus_slave.c modfunc_slave.c
    ../Driver/Dev/IO/: io.c
  group Pub
    ../Pub/: debug.h type_def.h
  group Utility
    ../Utility/: queue.c crc.c bittool.c
